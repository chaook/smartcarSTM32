# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_STM32100E_EVAL
  c include: .\CMSIS;.\DRIVER;.\HANDWARE\LED;.\HANDWARE\LCD;.\HANDWARE\PWM;.\HANDWARE\USART;.\HANDWARE\MOTOR;.\HANDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group USER
    ./USER/: mian.c
  group DRIVER
    ./DRIVER/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c
  group HANDWARE
    ./HANDWARE/LED/: led.c
    ./HANDWARE/LCD/: lcd.c
    ./HANDWARE/PWM/: pwm.c
    ./HANDWARE/USART/: usart.c
    ./HANDWARE/MOTOR/: motor.c
